# IAR project exoboot.ewp, settings and files
configuration stm32f405 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F405RG ST STM32F405RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F40XX; NO_EXCEPTIONS; NO_RTTI
  ICCARM.CCIncludePath2: ; D:\projects\iar\components\stm32++\lib\CMSIS\Device\ST\STM32F4xx\Include; D:\projects\iar\components\stm32++\lib\STM32F407_StdPeriph_Driver\inc; d:\projects\iar\components\stm32++\src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: headarm.srec
  ILINK.IlinkOutputFile: exoboot.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: config.h main.cpp
    ../../components/stm32++/lib/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
  group stm32f405
    ../../components/stm32++/bin/stm32f405rg_no-exceptions_no-rtti/: stm32++.a
    ../../components/stm32++/lib/STM32F407_StdPeriph_Driver/lib/: STM32F405RG_StdPeriph_Driver.a
